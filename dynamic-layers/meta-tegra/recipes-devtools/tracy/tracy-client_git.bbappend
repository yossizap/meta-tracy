FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://0001-tracy-cuda-support-cupti-12.patch"
